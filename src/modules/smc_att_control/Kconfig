## src/modules/smc_att_control/Kconfig
```kconfig
menuconfig MODULES_SMC_ATT_CONTROL
	bool "smc_att_control"
	default n
	---help---
		Enable support for smc_att_control
```
